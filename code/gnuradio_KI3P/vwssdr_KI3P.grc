options:
  parameters:
    author: Oliver KI3P
    generate_options: qt_gui
    id: vws_Sdr_KI3P
    output_language: python
    title: VWSSDR Receiver
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: '0.1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-gain'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: phase
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: phase
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if phase < 0 else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if phase < 0 else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt, serial

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, serial_port='/dev/ttyACM0'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Update tune frequency',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.serial_port = serial_port
              self.frequencyPortName = 'frequencyPort'
              self.message_port_register_in(pmt.intern(self.frequencyPortName))
              self.set_msg_handler(pmt.intern(self.frequencyPortName), self.handle_msg)
              self.new_center_freq = 10000
              self.center_freq = 10000
              self.serial = serial.Serial(self.serial_port,115200)
              return

          def handle_msg(self, msg):
              self.new_center_freq = pmt.to_long(msg)
              if (self.new_center_freq != self.center_freq):
                  print("Updated frequency %d"%self.new_center_freq)
                  self.serial.write(b'FR %d\n'%(self.new_center_freq*1000))
                  self.center_freq = self.new_center_freq
              return

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if (self.new_center_freq != self.center_freq):
                  print("Updated frequency %d"%self.new_center_freq)
                  self.center_freq = self.new_center_freq
              return 
    serial_port: '"/dev/ttyACM0"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Use "aplay -l" to get the sound card hardware address
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_0_0
  id: note
  parameters:
    note: amp*L+phs*R
  states: {}
- name: note_1_0_0_0_0
  id: note
  parameters:
    note: amp*L+phs*R
  states: {}
- name: note_1_0_0_1
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    note: phs*amp*L
  states: {}
- name: note_1_0_1_0
  id: note
  parameters:
    note: R+phs*amp*L
  states: {}
- name: note_1_0_1_0_0
  id: note
  parameters:
    note: R+phs*amp*L
  states: {}
- name: note_1_1_0
  id: note
  parameters:
    note: phs*R
  states: {}
- name: note_1_1_1
  id: note
  parameters:
    note: R
  states: {}
- name: note_1_1_1_0
  id: note
  parameters:
    note: R
  states: {}
- name: note_1_1_1_0_0
  id: note
  parameters:
    note: 'phs>0:'
  states: {}
- name: note_1_1_1_0_0_0
  id: note
  parameters:
    note: 'phs<0:'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: frequency_kHz
    label: Center Frequency [kHz]
    type: int
    value: '10000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_add_xx_0_0, '1']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [audio_source_0, '1', blocks_selector_0_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0, '1']
- [blocks_add_xx_0_0, '0', blocks_selector_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_selector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_selector_0_0, '0', blocks_float_to_complex_0, '1']
- [qtgui_edit_box_msg_0, msg, epy_block_0, frequencyPort]

metadata:
  file_format: 1
