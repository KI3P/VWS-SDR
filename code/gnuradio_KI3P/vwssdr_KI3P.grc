options:
  parameters:
    author: Oliver KI3P
    generate_options: qt_gui
    id: vws_Sdr_KI3P
    output_language: python
    title: VWSSDR Receiver
  states: {}

blocks:
- name: bfo
  id: variable_qtgui_range
  parameters:
    comment: 4,0,1,3
    gui_hint: 4,0,1,3
    label: Fine tuning
    start: '0'
    step: '10'
    stop: '3000'
    value: '1500'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: if_freq_kHz
  id: variable
  parameters:
    value: '6'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    comment: 3,2,1,1
    gui_hint: 3,2,1,1
    label: Sideband
    label0: Upper
    label1: Lower
    label2: BFO
    num_opts: '3'
    option0: '-1'
    option1: '1'
    option2: '0'
    orient: Qt.QHBoxLayout
    type: raw
    value: '-1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 2,0,1,3
    gui_hint: 2,0,1,3
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-gain'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: phase
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: phase
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: USB/LSB
    const: reverse
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if phase < 0 else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if phase < 0 else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt, serial

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, serial_port=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Update tune frequency',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.serial_port = serial_port
              self.frequencyPortName = 'frequencyPort'
              self.message_port_register_in(pmt.intern(self.frequencyPortName))
              self.set_msg_handler(pmt.intern(self.frequencyPortName), self.handle_msg)
              self.new_center_freq = 10000
              self.center_freq = 10000
              self.IF_frequency_kHz = 6
              if self.serial_port is not None:
                  self.serial = serial.Serial(self.serial_port,115200)
              return

          def handle_msg(self, msg):
              self.new_center_freq = pmt.to_long(msg) - self.IF_frequency_kHz
              if (self.new_center_freq != self.center_freq):
                  print("Updated frequency %d"%self.new_center_freq)
                  self.serial.write(b'FR %d\n'%(self.new_center_freq*1000))
                  self.center_freq = self.new_center_freq
              return

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if (self.new_center_freq != self.center_freq):
                  print("Updated frequency %d"%self.new_center_freq)
                  self.center_freq = self.new_center_freq
              return 
    serial_port: '"/dev/ttyACM1"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq_kHz*1000
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,3000, 200)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Use "aplay -l" to get the sound card hardware address
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_0_0
  id: note
  parameters:
    note: amp*L+phs*R
  states: {}
- name: note_1_0_0_0_0
  id: note
  parameters:
    note: amp*L+phs*R
  states: {}
- name: note_1_0_0_1
  id: note
  parameters:
    note: amp*L
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    note: phs*amp*L
  states: {}
- name: note_1_0_1_0
  id: note
  parameters:
    note: R+phs*amp*L
  states: {}
- name: note_1_0_1_0_0
  id: note
  parameters:
    note: R+phs*amp*L
  states: {}
- name: note_1_1_0
  id: note
  parameters:
    note: phs*R
  states: {}
- name: note_1_1_1
  id: note
  parameters:
    note: R
  states: {}
- name: note_1_1_1_0
  id: note
  parameters:
    note: R
  states: {}
- name: note_1_1_1_0_0
  id: note
  parameters:
    note: 'phs>0:'
  states: {}
- name: note_1_1_1_0_0_0
  id: note
  parameters:
    note: 'phs<0:'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: frequency_kHz
    label: Tune Frequency [kHz]
    type: int
    value: '10000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_add_xx_0_0, '1']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [audio_source_0, '1', blocks_selector_0_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0, '1']
- [blocks_add_xx_0_0, '0', blocks_selector_0_0, '0']
- [blocks_add_xx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_selector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_selector_0_0, '0', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0, frequencyPort]

metadata:
  file_format: 1
