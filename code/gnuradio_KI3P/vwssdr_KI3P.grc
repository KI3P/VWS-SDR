options:
  parameters:
    author: Oliver KI3P
    generate_options: qt_gui
    id: vws_Sdr_KI3P
    output_language: python
    title: VWSSDR Receiver
  states: {}

blocks:
- name: audio_lowpass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '2700'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: bfo
  id: variable_qtgui_range
  parameters:
    comment: Adjust the fine tune frequency
    gui_hint: 1,1,1,2
    label: Fine tuning
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Adjust the I/Q gain balance
    gui_hint: 5,0,1,3
    start: '-0.5'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: if_freq_kHz
  id: variable
  parameters:
    value: '6'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    comment: Adjust the I/Q phase balance
    gui_hint: 4,0,1,3
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label: Sideband
    label0: Upper
    label1: Lower
    label2: BFO
    num_opts: '3'
    option0: '-1'
    option1: '1'
    option2: '0'
    orient: Qt.QHBoxLayout
    type: raw
    value: '-1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tune_freq_kHz
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,2
    label: Volume
    start: '0'
    step: '0.5'
    stop: '50'
    value: '1.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: |-
      In linux, use "arecord -l" to get 
      the sound card hardware address
    device_name: hw:0,0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: 1/10
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: 1/10
    type: float
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: tune_freq_kHz
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: USB/LSB
    const: reverse
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt, serial

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, serial_port=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Update tune frequency',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.serial_port = serial_port
              self.frequencyPortName = 'frequencyPort'
              self.message_port_register_in(pmt.intern(self.frequencyPortName))
              self.set_msg_handler(pmt.intern(self.frequencyPortName), self.handle_msg)
              self.new_center_freq = 10000
              self.center_freq = 10000
              self.IF_frequency_kHz = 6
              if self.serial_port is not None:
                  self.serial = serial.Serial(self.serial_port,115200)
              return

          def handle_msg(self, msg):
              #self.new_center_freq = pmt.to_long(pmt.cdr(msg)) - self.IF_frequency_kHz
              self.new_center_freq = pmt.to_float(pmt.cdr(msg)) - self.IF_frequency_kHz
              if (self.new_center_freq != self.center_freq):
                  print("Updated frequency %d"%self.new_center_freq)
                  self.serial.write(b'FR %d\n'%(self.new_center_freq*1000))
                  self.center_freq = self.new_center_freq
              return

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if (self.new_center_freq != self.center_freq):
                  self.center_freq = self.new_center_freq
              return 
    serial_port: '"/dev/ttyACM0"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vectorSize=2048):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='SNR measurement',   # will show up in GRC
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[np.float32,np.float32]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for vectorIndex in range(len(input_items[0])):
                  d = input_items[0][vectorIndex]
                  I = np.argmax(d)
                  # Find the average of the 50 bins around this maximum bin, but exclude 10 bins on each side
                  ind = np.arange(len(d))
                  window1 = (ind > (I+10)) & (ind < (I+30))
                  window2 = (ind < (I-10)) & (ind > (I-30))
                  window = window1 | window2
                  noise = np.mean(d[window])
                  signal = d[I]
                  SNR = 10*np.log10(signal/noise)
                  # If the input is -73 dBm, then the noise floor is
                  floor = -73.0 - SNR
                  #output_items[0][vectorIndex] = signal
                  #output_items[1][vectorIndex] = noise
                  output_items[0][vectorIndex] = SNR
                  output_items[1][vectorIndex] = floor

              return len(output_items[0])
    comment: |-
      Calculate the amplitude of the 
      largest tone and the noise floor 
      on either side of it
    vectorSize: fft_len
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: audio_lowpass
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq_kHz*1000
    comment: |-
      Filter a band 6 kHz wide centered on if_freq_kHz. Then translate
      if_freq_kHz to DC. So an input signal at (if_freq_kHz + tone_kHz) 
      will be at (tone_kHz) after this step.
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,3000, 200)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: gain
    phase: phase
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,1
    key: frequency_kHz
    label: Tune Frequency [kHz]
    type: float
    value: '10000'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,0,1,1
    name: '"SNR [dB]"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,1,1,1
    name: '"Noise floor [dBm]"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: Widget to display spectrum, waterfall, etc.
    fc: (tune_freq_kHz-if_freq_kHz)*1000
    fftsize: '1024'
    gui_hint: 0,0,1,3
    name: '"RF Signal Display"'
    plotconst: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/8
    comment: Display the audio waveform
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,3
    name: '"Demodulated Audio Signal Display"'
    plotconst: 'False'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_0_0, '1']
- [audio_source_0, '1', blocks_float_to_complex_0_0, '0']
- [blocks_add_xx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0_0, '0']
- [blocks_float_to_complex_0_0, '0', iqbalance_fix_cc_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_0_0, '1', blocks_moving_average_xx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [iqbalance_fix_cc_0, '0', blocks_stream_to_vector_0, '0']
- [iqbalance_fix_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iqbalance_fix_cc_0, '0', qtgui_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_msgpair_to_var_0, inpair]
- [qtgui_edit_box_msg_0, msg, epy_block_0, frequencyPort]

metadata:
  file_format: 1
